DESCRIPTION = "rpi secure ausweis image swupdate compound image"

FILESEXTRAPATHS:prepend := "${RPI_SECURE_BASE}/recipes-core/images/files:"

require recipes-core/images/rpi-secure-image-update.inc