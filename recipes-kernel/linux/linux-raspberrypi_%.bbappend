FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://framebuffer.cfg"
